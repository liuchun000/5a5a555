# Keil uVision project STM32F429_APP.uvprojx, settings and files
target STM32F429_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F429_APP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Core;..\Core\STMFLASH;..\Core\UDS_DriverConfig;..\Core\UDS_PortingFiles;..\Core\UDS_ProtocolStack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32F429_APP\STM32F429_APP.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/STMFLASH/: stmflash.c
    ../Core/Src/: main.c gpio.c can.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group UDS_DriverConfig
    ../Core/UDS_DriverConfig/: can_cfg.c can_driver.c flash.c flash_cfg.c
  group UDS_PortingFiles
    ../Core/UDS_PortingFiles/: AES.c boot.c boot_Cfg.c bootloader_debug.c CRC_hal.c debug_IO.c debug_timer.c flash_hal.c flash_hal_Cfg.c timer_hal.c UDS_alg_hal.c watchdog_hal.c ZLGKey.c user_config.h
  group UDS_ProtocolStack
    ../Core/UDS_ProtocolStack/: autolibc.c bootloader_main.c can_tp.c can_tp_cfg.c fls_app.c LIN_tp.c LIN_tp_cfg.c multi_cyc_fifo.c TP.c TP_cfg.c uds_app.c uds_app_cfg.c
software components: CMSIS:CORE 4.3.0
